# Keil uVision project BalanceCar.uvprojx, settings and files
target BalanceCar_MSPM0G3507 (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BalanceCar_MSPM0G3507 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\firmware\app;..\..\firmware\control;..\..\firmware\control\line_follow;..\..\firmware\commissioning;..\..\firmware\drivers\motor;..\..\firmware\drivers\encoder;..\..\firmware\drivers\imu;..\..\firmware\drivers\imu\mpu6050;..\..\firmware\drivers\display\oled;..\..\firmware\platform;..\..\firmware\config;..\..\firmware\generated;..\..\vendor\arm\CMSIS\Core\Include;..\..\vendor\ti\mspm0_sdk\source;..\..\vendor\ti\driverlib_port
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: ..\..\vendor\ti\mspm0_sdk\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group 01 Application
    ../../firmware/app/: main.c
    ../../firmware/config/: project_identity.c
  group 02 Generated Configuration
    ./: BalanceCar.syscfg
    ../../firmware/generated/: ti_msp_dl_config.h ti_msp_dl_config.c
  group 03 Platform
    ./: startup_mspm0g350x_uvision.s
    ../../firmware/platform/: board.c hw_timer.c system_time.c
  group 04 Balance Control
    ../../firmware/control/: control.c
  group 05 Line Follow
    ../../firmware/control/line_follow/: trace_sensor.c balance_line_follow.c
  group 06 Commissioning
    ../../firmware/commissioning/: imu_startup.c commissioning.c
  group 07 Device Drivers
    ../../firmware/drivers/display/oled/: oled.c
    ../../firmware/drivers/motor/: tb6612.c
    ../../firmware/drivers/encoder/: hw_encoder.c
    ../../firmware/drivers/imu/: jy61p.c
    ../../firmware/drivers/imu/mpu6050/: mpu6050.c mspm0_i2c.c inv_mpu.c inv_mpu_dmp_motion_driver.c
  group 08 TI DriverLib
    ../../vendor/ti/driverlib_port/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
